# Keil uVision project ecbm.uvproj, settings and files
target ECBM V3 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ecbm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ECBM_LIB;.\device
  group 用户文件
    ./: main.c STARTUP.A51
  group 配置文件/头文件
    ./ECBM_LIB/: ecbm_reg.h ecbm_core.h gpio.h power.h uart.h exti.h timer.h eeprom.h spi.h soft_spi.h iic.h soft_iic.h adc.h cmp.h mdu16.h pca.h pwm.h lcm.h nvic.h led.h eds.h lcd.h stream.h stream_ecp.h stream_fur.h stream_modbus.h
  group 库本体/C文件
    ./ECBM_LIB/: ecbm_core.c gpio.c power.c uart.c exti.c timer.c eeprom.c spi.c soft_spi.c iic.c soft_iic.c adc.c cmp.c mdu16.c pca.c pwm.c lcm.c nvic.c led.c lcd.c eds.c stream.c stream_ecp.c stream_fur.c stream_modbus.c
