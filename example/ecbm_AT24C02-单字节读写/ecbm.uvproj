# Keil uVision project ecbm.uvproj, settings and files
target STC8 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ecbm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ECBM_LIB;.\device
  group USER
    ./: STARTUP.A51 main.c
  group LIB_LIST
    ./ECBM_LIB/: ecbm_core.h power.h gpio.h eeprom.h exti.h soft_iic.h iic.h soft_spi.h spi.h adc.h pwm.h uart.h cmp.h timer.h mdu16.h pca.h it.h
  group ECBM_LIB
    ./ECBM_LIB/: ecbm_core.c power.c gpio.c eeprom.c exti.c soft_iic.c iic.c soft_spi.c spi.c adc.c pwm.c uart.c cmp.c timer.c mdu16.c pca.c it.c
  group DEVICE
    ./device/: at24cxx.c
